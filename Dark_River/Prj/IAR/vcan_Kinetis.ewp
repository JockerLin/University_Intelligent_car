# IAR project vcan_Kinetis.ewp, settings and files
configuration FN15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FN15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
configuration FX15_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\App; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\App\Inc; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\Board\inc; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\Chip\inc; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\Chip\inc\IAR; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\Chip\inc\kinetis; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\Lib\CMSIS\Inc; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\Lib\FatFs; F:\斯达迪\freescale\【验证及调试】\“暗湧六號D”\Dark_River\Lib\USB
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  group App
    ../../App/: Car_Control.c fuzzy.c get_midline.c IIC_Sim.c IIC_Sim.h Key.c main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: PORT_cfg.h
  group Board
    ../../Board/src/: VCAN_ASCII.c VCAN_BMP.c VCAN_camera.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_OV7725_Wolf.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../../Chip/src/: 8700_2100.c misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c Serial_oscilloscope.c vectors.c
    ../../Chip/inc/: 8700_2100.h common.h
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
